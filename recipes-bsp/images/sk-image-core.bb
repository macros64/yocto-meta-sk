inherit core-image

LICENSE = ""

IMAGE_FEATURES += " splash"

