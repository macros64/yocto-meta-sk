COMPATIBLE_MACHINE = "(sk-imx6q|sk-holaduo)"
