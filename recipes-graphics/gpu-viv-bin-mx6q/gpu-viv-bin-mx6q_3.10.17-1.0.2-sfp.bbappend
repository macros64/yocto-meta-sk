COMPATIBLE_MACHINE = "(sk-imx6q|sk-holaduo)"
PROVIDES_append  = " virtual/libgl virtual/libgles1 virtual/libgles2"
